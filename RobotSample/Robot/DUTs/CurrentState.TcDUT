{attribute 'qualified_only'}
{attribute 'strict'}
TYPE CurrentState :
(
	Init := 0,
	Waiting := 10,
	Catchmaterial	:= 20,
	Calibration := 30,
	Error := 99
);
END_TYPE
